# Keil uVision project main.uvproj, settings and files
target main (ARM-ADS)
  device: M052LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x1FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: main +hex
  AfterMake: fromelf --bin ".\output\@L.axf" --output ".\output\@L.bin"
  AfterMake: fromelf --text -c ".\output\@L.axf" --output ".\output\@L.txt"
  c flags: Optim=3
  c include: ..\Include
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group SOURCE
    ./: main.c
  group framework
    ../framework/: startup_M051Series.s ADC.c check.c common.c dataprocess.c function.c GPIO.c I2C.c mytimer.c PLL.c queue.c retarget.c spi.c uatr.c watchdog.c
